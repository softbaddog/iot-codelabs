# Keil uVision project NBIOT.uvprojx, settings and files
target NBIOT (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NBIOT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,LOS_STM32L476VE
  c include: ..\USER;..\CORE;..\HALLIB\STM32L4xx_HAL_Driver\Inc;..\SYSTEM;..\HAREWARE\bc95;..\HAREWARE\enc28j60;..\LiteOS_Kernel\include;..\LiteOS_Kernel\link\keil;..\LiteOS_Kernel\cmsis;..\LiteOS_Kernel\config;..\LiteOS_Kernel\cpu\arm\cortex-m4;..\LiteOS_Kernel\base\include;..\LiteOS_Netport\agenttiny;..\LiteOS_Netport\microcoap;..\LiteOS_Netport\microtcpip;..\LiteOS_Netport\ocean;..\LiteOS_Netport\umini;..\TESTS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group USER
    ./: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l476xx.s
  group HALLIB
    ../HALLIB/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c
  group SYSTEM
    ../SYSTEM/: los_bsp_adapter.c los_bsp_flash.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c los_dev_st_spi.c los_dev_st_uart.c
  group HAREWARE
    ../HAREWARE/enc28j60/: enc28j60.c
    ../HAREWARE/bc95/: neul_bc95.c
  group LiteOS_Kernel
    ../LiteOS_Kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS_Kernel/cmsis/: cmsis_liteos.c
    ../LiteOS_Kernel/config/: los_config.c
    ../LiteOS_Kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS_Kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../LiteOS_Kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
    ../LiteOS_Kernel/base/misc/: los_misc.c
  group LiteOS_Netport
    ../LiteOS_Netport/agenttiny/: agent_client_interface.c Agenttiny.c
    ../LiteOS_Netport/microcoap/: coap.c coap_liteos_port.c endpoints.c
    ../LiteOS_Netport/ocean/: ocean_interface.c ocean_porting.c
    ../LiteOS_Netport/umini/: umini_extern.c
    ../LiteOS_Netport/microtcpip/: microtcpip.c udp_coap_interface.c
  group TESTS
    ../TESTS/: gpio_handle.c key_test.c ocean_sample.c th_sensor.c uart_test.c
