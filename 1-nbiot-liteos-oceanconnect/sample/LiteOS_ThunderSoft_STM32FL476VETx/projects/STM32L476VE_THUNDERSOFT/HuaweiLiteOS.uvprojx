# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,LOS_STM32L476VE
  c include: ..\..\example\include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m3;..\..\kernel\cmsis;..\..\platform\STM32L476VE_THUNDERSOFT;..\..\netprot\microcoap;..\..\netprot\microtcpip;..\..\peripheral;..\..\oceaninterface;..\..\oceaninterface\agenttiny;..\..\oceaninterface\nb;..\..\user;..\..\BSP\STM32L476VETx\Inc;..\..\BSP\STM32L476VETx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\BSP\STM32L476VETx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\BSP\STM32L476VETx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\BSP\STM32L476VETx\Drivers\CMSIS\Include;..\..\sensors;..\..\sensors
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group cpu/cm4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group platform/stm32l476ve
    ../../platform/STM32L476VE_THUNDERSOFT/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c los_dev_st_spi.c los_dev_st_uart.c
  group BSP/STM32L476VETx
    ../../BSP/STM32L476VETx/Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
    ../../BSP/STM32L476VETx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group oceaninterface
    ../../oceaninterface/: ocean_interface.c
    ../../oceaninterface/agenttiny/: Agenttiny.c ocean_porting.c umini_extern.c agent_client_interface.c
  group netprot/microtcpip
    ../../netprot/microtcpip/: microtcpip.c udp_coap_interface.c
  group netprot/microcoap
    ../../netprot/microcoap/: coap.c coap_liteos_port.c endpoints.c
  group peripherals/neulbc95
    ../../peripheral/: neul_bc95.c
  group peripherals/spienc28j60
    ../../peripheral/: spi_enc28j60.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../BSP/STM32L476VETx/MDK-ARM/: startup_stm32l476xx.s
  group sensors
    ../../sensors/: th_sensor.c gpio_handle.c
  group user
    ../../user/: main.c ocean_sample.c uart_test.c delay.c key_test.c
