# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L452VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00028000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L452xx,LOS_STM32L452VE
  c include: ..\..\example\include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m3;..\..\kernel\cmsis;..\..\platform\STM32L452VE_THUNDERSOFT;..\..\netprot\microcoap;..\..\netprot\microtcpip;..\..\peripheral;..\..\oceaninterface;..\..\oceaninterface\agenttiny;..\..\oceaninterface\nb;..\..\user;..\..\BSP\STM32L452VETx\Inc;..\..\BSP\STM32L452VETx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\BSP\SSTM32L452VETx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\BSP\STM32L452VETx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\BSP\STM32L452VETx\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group cpu/cm4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group platform/stm32l452ve
    ../../platform/STM32L452VE_THUNDERSOFT/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c los_dev_st_uart.c los_dev_st_spi.c
  group BSP/STM32L452VETx
    ../../BSP/STM32L452VETx/Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
    ../../BSP/STM32L452VETx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group oceaninterface
    ../../oceaninterface/: ocean_interface.c
    ../../oceaninterface/agenttiny/: Agenttiny.c ocean_porting.c umini_extern.c agent_client_interface.c
  group netprot/microtcpip
    ../../netprot/microtcpip/: microtcpip.c udp_coap_interface.c
  group netprot/microcoap
    ../../netprot/microcoap/: coap.c coap_liteos_port.c endpoints.c
  group peripherals/neulbc95
    ../../peripheral/: neul_bc95.c
  group peripherals/spienc28j60
    ../../peripheral/: spi_enc28j60.c
  group startup
    ../../BSP/STM32L452VETx/MDK-ARM/: startup_stm32l452xx.s
  group user
    ../../user/: main.c max7219_driver_func.c ocean_sample.c
